#pragma once
// DisplayGfx — tiny monochrome graphics layer for a 128x32 SSD1306 OLED.
//
// Hardware independent on purpose (no Arduino/Wire includes): the framebuffer,
// font and marquee maths can be compiled and checked on a host PC
// (see tools/test_display_gfx.cpp), while DisplayController.cpp owns the I2C
// driver and the state machine.
//
// Framebuffer layout matches the SSD1306 GDDRAM: 4 pages of 128 columns, one
// byte = 8 vertically stacked pixels, LSB on top.  buf[page * 128 + x].
#include <stdint.h>
#include <string.h>

namespace DisplayGfx
{
    static constexpr int W      = 128;
    static constexpr int H      = 32;
    static constexpr int PAGES  = H / 8;
    static constexpr int GLYPH_W = 5;                // columns per glyph
    static constexpr int GLYPH_H = 7;                // rows per glyph
    static constexpr int ADVANCE = GLYPH_W + 1;      // glyph + 1 column spacing

    // Classic 5x7 ASCII font, 0x20 (space) .. 0x7E (~). One byte per column,
    // bit 0 = top row.
    static const uint8_t FONT5X7[95 * GLYPH_W] = {
        0x00,0x00,0x00,0x00,0x00, 0x00,0x00,0x5F,0x00,0x00, 0x00,0x07,0x00,0x07,0x00, // sp ! "
        0x14,0x7F,0x14,0x7F,0x14, 0x24,0x2A,0x7F,0x2A,0x12, 0x23,0x13,0x08,0x64,0x62, // # $ %
        0x36,0x49,0x55,0x22,0x50, 0x00,0x05,0x03,0x00,0x00, 0x00,0x1C,0x22,0x41,0x00, // & ' (
        0x00,0x41,0x22,0x1C,0x00, 0x14,0x08,0x3E,0x08,0x14, 0x08,0x08,0x3E,0x08,0x08, // ) * +
        0x00,0x50,0x30,0x00,0x00, 0x08,0x08,0x08,0x08,0x08, 0x00,0x60,0x60,0x00,0x00, // , - .
        0x20,0x10,0x08,0x04,0x02, 0x3E,0x51,0x49,0x45,0x3E, 0x00,0x42,0x7F,0x40,0x00, // / 0 1
        0x42,0x61,0x51,0x49,0x46, 0x21,0x41,0x45,0x4B,0x31, 0x18,0x14,0x12,0x7F,0x10, // 2 3 4
        0x27,0x45,0x45,0x45,0x39, 0x3C,0x4A,0x49,0x49,0x30, 0x01,0x71,0x09,0x05,0x03, // 5 6 7
        0x36,0x49,0x49,0x49,0x36, 0x06,0x49,0x49,0x29,0x1E, 0x00,0x36,0x36,0x00,0x00, // 8 9 :
        0x00,0x56,0x36,0x00,0x00, 0x08,0x14,0x22,0x41,0x00, 0x14,0x14,0x14,0x14,0x14, // ; < =
        0x00,0x41,0x22,0x14,0x08, 0x02,0x01,0x51,0x09,0x06, 0x32,0x49,0x79,0x41,0x3E, // > ? @
        0x7E,0x11,0x11,0x11,0x7E, 0x7F,0x49,0x49,0x49,0x36, 0x3E,0x41,0x41,0x41,0x22, // A B C
        0x7F,0x41,0x41,0x22,0x1C, 0x7F,0x49,0x49,0x49,0x41, 0x7F,0x09,0x09,0x09,0x01, // D E F
        0x3E,0x41,0x49,0x49,0x7A, 0x7F,0x08,0x08,0x08,0x7F, 0x00,0x41,0x7F,0x41,0x00, // G H I
        0x20,0x40,0x41,0x3F,0x01, 0x7F,0x08,0x14,0x22,0x41, 0x7F,0x40,0x40,0x40,0x40, // J K L
        0x7F,0x02,0x0C,0x02,0x7F, 0x7F,0x04,0x08,0x10,0x7F, 0x3E,0x41,0x41,0x41,0x3E, // M N O
        0x7F,0x09,0x09,0x09,0x06, 0x3E,0x41,0x51,0x21,0x5E, 0x7F,0x09,0x19,0x29,0x46, // P Q R
        0x46,0x49,0x49,0x49,0x31, 0x01,0x01,0x7F,0x01,0x01, 0x3F,0x40,0x40,0x40,0x3F, // S T U
        0x1F,0x20,0x40,0x20,0x1F, 0x3F,0x40,0x38,0x40,0x3F, 0x63,0x14,0x08,0x14,0x63, // V W X
        0x07,0x08,0x70,0x08,0x07, 0x61,0x51,0x49,0x45,0x43, 0x00,0x7F,0x41,0x41,0x00, // Y Z [
        0x02,0x04,0x08,0x10,0x20, 0x00,0x41,0x41,0x7F,0x00, 0x04,0x02,0x01,0x02,0x04, // \ ] ^
        0x40,0x40,0x40,0x40,0x40, 0x00,0x01,0x02,0x04,0x00, 0x20,0x54,0x54,0x54,0x78, // _ ` a
        0x7F,0x48,0x44,0x44,0x38, 0x38,0x44,0x44,0x44,0x20, 0x38,0x44,0x44,0x48,0x7F, // b c d
        0x38,0x54,0x54,0x54,0x18, 0x08,0x7E,0x09,0x01,0x02, 0x0C,0x52,0x52,0x52,0x3E, // e f g
        0x7F,0x08,0x04,0x04,0x78, 0x00,0x44,0x7D,0x40,0x00, 0x20,0x40,0x44,0x3D,0x00, // h i j
        0x7F,0x10,0x28,0x44,0x00, 0x00,0x41,0x7F,0x40,0x00, 0x7C,0x04,0x18,0x04,0x78, // k l m
        0x7C,0x08,0x04,0x04,0x78, 0x38,0x44,0x44,0x44,0x38, 0x7C,0x14,0x14,0x14,0x08, // n o p
        0x08,0x14,0x14,0x18,0x7C, 0x7C,0x08,0x04,0x04,0x08, 0x48,0x54,0x54,0x54,0x20, // q r s
        0x04,0x3F,0x44,0x40,0x20, 0x3C,0x40,0x40,0x20,0x7C, 0x1C,0x20,0x40,0x20,0x1C, // t u v
        0x3C,0x40,0x30,0x40,0x3C, 0x44,0x28,0x10,0x28,0x44, 0x0C,0x50,0x50,0x50,0x3C, // w x y
        0x44,0x64,0x54,0x4C,0x44, 0x00,0x08,0x36,0x41,0x00, 0x00,0x00,0x7F,0x00,0x00, // z { |
        0x00,0x41,0x36,0x08,0x00, 0x10,0x08,0x08,0x10,0x08,                            // } ~
    };

    // Width in pixels of `s` drawn at `scale` (no trailing spacing column).
    static inline int textWidth(const char *s, int scale)
    {
        int n = (int)strlen(s);
        return n == 0 ? 0 : (n * ADVANCE - 1) * scale;
    }

    struct Frame
    {
        uint8_t buf[W * PAGES];

        void clear() { memset(buf, 0, sizeof(buf)); }

        void setPixel(int x, int y)
        {
            if (x < 0 || x >= W || y < 0 || y >= H) return;
            buf[(y >> 3) * W + x] |= (uint8_t)(1u << (y & 7));
        }

        // Filled rectangle, clipped to the display and to columns [clipX0, clipX1).
        void fillRect(int x, int y, int w, int h, int clipX0 = 0, int clipX1 = W)
        {
            for (int yy = y; yy < y + h; ++yy)
                for (int xx = x; xx < x + w; ++xx)
                    if (xx >= clipX0 && xx < clipX1) setPixel(xx, yy);
        }

        // Hollow rectangle, 1 px border.
        void drawRect(int x, int y, int w, int h)
        {
            fillRect(x, y, w, 1);
            fillRect(x, y + h - 1, w, 1);
            fillRect(x, y, 1, h);
            fillRect(x + w - 1, y, 1, h);
        }

        // One glyph at (x, y) = top-left. Anything that is not printable ASCII
        // is drawn as '?'. Only columns inside [clipX0, clipX1) are touched, so
        // a marquee can scroll text through a band without bleeding out of it.
        void drawChar(int x, int y, char c, int scale, int clipX0, int clipX1)
        {
            if ((unsigned char)c < 0x20 || (unsigned char)c > 0x7E) c = '?';
            const uint8_t *g = &FONT5X7[(c - 0x20) * GLYPH_W];
            for (int col = 0; col < GLYPH_W; ++col)
                for (int row = 0; row < GLYPH_H; ++row)
                    if (g[col] & (1u << row))
                        fillRect(x + col * scale, y + row * scale, scale, scale, clipX0, clipX1);
        }

        // Text starting at pixel column x (may be negative). Returns the width drawn.
        int drawText(int x, int y, const char *s, int scale, int clipX0 = 0, int clipX1 = W)
        {
            int cx = x;
            for (const char *p = s; *p; ++p, cx += ADVANCE * scale)
            {
                if (cx >= clipX1) break;                       // fully right of the band
                if (cx + GLYPH_W * scale <= clipX0) continue;  // fully left of the band
                drawChar(cx, y, *p, scale, clipX0, clipX1);
            }
            return textWidth(s, scale);
        }
    };

    // Horizontal marquee for text that is wider than its band: hold at the
    // start, then scroll left by `scale` pixels per step, wrapping with a gap.
    struct Marquee
    {
        static constexpr int      GAP_PX       = 24;    // blank run between the end and the restart
        static constexpr int      STEP_PX      = 2;     // pixels per step
        static constexpr uint32_t STEP_MS      = 60;    // step cadence  (~33 px/s)
        static constexpr uint32_t HOLD_MS      = 1500;  // pause at the start position

        int      width  = 0;      // text width in px
        int      offset = 0;      // current scroll offset in px
        uint32_t nextMs = 0;      // when the next step is due

        bool scrolls() const { return width > W; }

        void reset(int textW, uint32_t now)
        {
            width = textW;
            offset = 0;
            nextMs = now + HOLD_MS;
        }

        // Advance to `now`. Returns true if the offset changed (=> redraw needed).
        bool step(uint32_t now)
        {
            if (!scrolls() || (int32_t)(now - nextMs) < 0) return false;
            offset += STEP_PX;
            if (offset >= width + GAP_PX)
            {
                offset = 0;
                nextMs = now + HOLD_MS;
            }
            else
            {
                nextMs = now + STEP_MS;
            }
            return true;
        }
    };
}
